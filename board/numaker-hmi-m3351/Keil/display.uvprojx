# Keil uVision project display.uvprojx, settings and files
target NUTFT (6240000::V6.24::ARMCLANG)
  device: M3351KJCAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x30000000,0x20000) IROM(0x00000000,0x100000) IROM2(0x10000000,0x100000) IROM3(0x0F100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: display_nutft
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=1
  c define: CONFIG_DISP_ILI9341=1
  c include: ..\;..\..\..\bsp\m3351\Library\CMSIS\Core\Include;..\..\..\bsp\m3351\Library\CMSIS\Compiler\include;..\..\..\bsp\m3351\Library\Device\Nuvoton\M3351\Include;..\..\..\bsp\m3351\Library\StdDriver\inc;..\plat_driver;..\..\..\common;..\..\..\common\drv_disp;..\..\..\common\drv_indev
  asm define: M487JI
  asm include: ..\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\M3351.scf
  group src
    ../: main.c
  group libraries
    ../../../bsp/m3351/Library/StdDriver/src/: clk.c gpio.c pdma.c retarget.c sys.c uart.c eadc.c timer.c spi.c
    ../../../bsp/m3351/Library/Device/Nuvoton/M3351/Source/: startup_M3351.c system_M3351.c
  group plat_driver
    ../plat_driver/: drv_pdma.c drv_spi.c
  group display
    ../plat_driver/: disp_glue.c disp_glue.h
  group touch
    ../plat_driver/: touch_glue.c touch_glue.h
  group helper
    ../../../common/: nu_misc.c sw_crc.c perf_ev.c display_testcases.c
  group ILI9341_SPI
    ../../../common/drv_disp/: disp_ili9341.c ili9341_spi.c
    ../../../common/drv_indev/: touch_adc.c touch_adc_calibration.c
