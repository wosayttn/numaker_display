# Keil uVision project display.uvprojx, settings and files
target NUFUN (6240000::V6.24::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: IRAM(0x20000000,0x50000) IRAM2(0x30000000,0x50000) IROM(0x00000000,0x80000) IROM2(0x10000000,0x80000) IROM3(0x0F100000,0x2000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: display_nufun
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=1
  c define: CONFIG_DISP_ILI9341=1 NUFUN=1
  c include: ..\;..\..\..\bsp\m3331\Library\CMSIS\Core\Include;..\..\..\bsp\m3331\Library\Device\Nuvoton\m3331\Include;..\..\..\bsp\m3331\Library\StdDriver\inc;..\plat_driver;..\..\..\common;..\..\..\common\drv_disp;..\..\..\common\drv_indev
  asm define: M487JI
  asm include: ..\
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x30000000 size 0x50000
  scatter file: .\m3331.sct
  group src
    ../: main.c
  group libraries
    ../../../bsp/m3331/Library/StdDriver/src/: clk.c gpio.c pdma.c retarget.c sys.c uart.c eadc.c timer.c spi.c
    ../../../bsp/m3331/Library/Device/Nuvoton/m3331/Source/: startup_m3331.c system_m3331.c
  group plat_driver
    ../plat_driver/: drv_pdma.c drv_spi.c
  group display
    ../plat_driver/: disp_glue.c disp_glue.h
  group touch
    ../plat_driver/: touch_glue.c touch_glue.h
  group helper
    ../../../common/: nu_misc.c sw_crc.c perf_ev.c display_testcases.c
  group ILI9341_SPI
    ../../../common/drv_disp/: disp_ili9341.c ili9341_spi.c
    ../../../common/drv_indev/: touch_adc.c touch_adc_calibration.c
target NUTFT (6240000::V6.24::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: as above
  output: display_nutft
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: as above
  c define: CONFIG_DISP_ILI9341=1
  c include: as above
  asm define: M487JI
  asm include: ..\
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x30000000 size 0x50000
  scatter file: .\m3331.sct
