# Keil uVision project display.uvprojx, settings and files
target LCD5_V1_2 (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: display_lcd5_v1_2
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 v6Lto=1 wLevel=3
  c define: CONFIG_DISP_LT7381=1
  c include: ..\;..\..\..\bsp\m55m1\Library\CMSIS\DSP\Include;..\..\..\bsp\M55M1\Library\CMSIS\Core\Include;..\..\..\bsp\M55M1\Library\Device\Nuvoton\M55M1\Include;..\..\..\bsp\M55M1\Library\StdDriver\inc;..\plat_driver;..\..\..\common\drv_indev;..\..\..\common\drv_disp;..\..\..\common;..\..\..\
  asm define: M55M1
  asm include: ..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
  group src
    ../: main.c mpu_config_M55M1.h
  group libraries
    ../../../bsp/m55m1/Library/StdDriver/src/: clk.c ebi.c gpio.c pdma.c retarget.c sys.c uart.c timer.c spi.c i2c.c eadc.c
    ../../../bsp/m55m1/Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group display
    ../plat_driver/: disp_glue.c disp_glue.h
  group touch
    ../plat_driver/: touch_glue.c touch_glue.h
  group helper
    ../plat_driver/: drv_pdma.c drv_spi.c
    ../../../common/: nu_misc.c sw_crc.c perf_ev.c display_testcases.c
  group LCD43_V1_0
    ../../../common/drv_disp/: disp_fsa506.c fsa506_ebi.c
    ../../../common/drv_indev/: touch_st1663i.c
  group LCD43_V1_1
    ../../../common/drv_disp/: disp_nv3041a.c nv3041a_ebi.c
    ../../../common/drv_indev/: touch_gt911.c
  group LCD5_V1_2
    ../../../common/drv_disp/: disp_lt7381.c lt7381_ebi.c
    ../../../common/drv_indev/: touch_ft5316.c
  group NUTFT_V1_3
    ../../../common/drv_disp/: disp_ili9341.c ili9341_spi.c
    ../../../common/drv_indev/: touch_adc.c touch_adc_calibration.c
target LCD43_V1_1 (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: as above
  output: display_lcd43_v1_1
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: as above
  c define: CONFIG_DISP_NV3041A=1
  c include: ..\;..\..\..\bsp\m55m1\Library\CMSIS\DSP\Include;..\..\..\bsp\M55M1\Library\CMSIS\Core\Include;..\..\..\bsp\M55M1\Library\Device\Nuvoton\M55M1\Include;..\..\..\bsp\M55M1\Library\StdDriver\inc;..\plat_driver;..\..\..\common\drv_disp;..\..\..\common\drv_indev;..\..\..\common;..\..\..\
  asm define: M55M1
  asm include: ..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
target LCD43_V1_0 (6220000::V6.22::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: as above
  output: display_lcd43_v1_0
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: as above
  c define: CONFIG_DISP_FSA506=1
  c include: ..\;..\..\..\bsp\m55m1\Library\CMSIS\DSP\Include;..\..\..\bsp\M55M1\Library\CMSIS\Core\Include;..\..\..\bsp\M55M1\Library\Device\Nuvoton\M55M1\Include;..\..\..\bsp\M55M1\Library\StdDriver\inc;..\plat_driver;..\..\..\common\drv_disp;..\..\..\common\drv_indev;..\..\..\common
  asm define: M55M1
  asm include: ..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
target NUTFT_V1_3 (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: as above
  output: display_nutft_v1_3
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: as above
  c define: CONFIG_DISP_ILI9341=1
  c include: as above
  asm define: M55M1
  asm include: ..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
