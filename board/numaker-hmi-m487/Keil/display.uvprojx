# Keil uVision project display.uvprojx, settings and files
target M487_ADVANCE (6240000::V6.24::ARMCLANG)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x9FFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: display_m487_advance
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=1
  c define: CONFIG_DISP_ILI9341=1
  c include: ..\;..\..\..\bsp\m480\Library\CMSIS\Include;..\..\..\bsp\m480\Library\Device\Nuvoton\M480\Include;..\..\..\bsp\m480\Library\StdDriver\inc;..\plat_driver;..\..\..\common;..\..\..\common\drv_disp;..\..\..\common\drv_indev;..\plat_driver
  asm define: M487JI
  asm include: ..\
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group src
    ../: main.c
  group libraries
    ../../../bsp/m480/Library/StdDriver/src/: clk.c ebi.c gpio.c pdma.c retarget.c sys.c uart.c eadc.c timer.c
    ../../../bsp/m480/Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../bsp/m480/Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group plat_driver
    ../plat_driver/: drv_pdma.c
  group display
    ../plat_driver/: disp_glue.c disp_glue.h
  group touch
    ../plat_driver/: touch_glue.c touch_glue.h
  group helper
    ../../../common/: nu_misc.c sw_crc.c perf_ev.c display_testcases.c
  group M487_ADVANCE
    ../../../common/drv_disp/: disp_ili9341.c ili9341_ebi.c
    ../../../common/drv_indev/: touch_adc.c touch_adc_calibration.c
