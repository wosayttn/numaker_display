# Keil uVision project display.uvprojx, settings and files
target LCD43_V1_1 (6240000::V6.24::ARMCLANG)
  device: M467HJHAN Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.1
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) IROM2(0x0F100000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: display_lcd43_v1_1
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=4 v6Lto=1 wLevel=3
  c define: CONFIG_DISP_NV3041A=1
  c include: ..\;..\..\..\bsp\m460\Library\CMSIS\Include;..\..\..\bsp\m460\Library\Device\Nuvoton\m460\Include;..\..\..\bsp\m460\Library\StdDriver\inc;..\plat_driver;..\..\..\common\drv_disp;..\..\..\common\drv_indev;..\..\..\common
  asm define: m460
  asm include: ..\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0xf100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group src
    ../: main.c
  group libraries
    ../../../bsp/m460/Library/StdDriver/src/: clk.c ebi.c gpio.c pdma.c sys.c uart.c timer.c retarget.c spi.c i2c.c eadc.c
    ../../../bsp/m460/Library/Device/Nuvoton/m460/Source/: system_m460.c
    ../../../bsp/m460/Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.S
  group display
    ../plat_driver/: disp_glue.c disp_glue.h
  group touch
    ../plat_driver/: touch_glue.c touch_glue.h
  group helper
    ../plat_driver/: drv_pdma.c drv_spi.c
    ../../../common/: nu_misc.c display_testcases.c sw_crc.c perf_ev.c
    ../../../common/drv_indev/: plat_touch.c
  group LCD43_V1_0
    ../../../common/drv_disp/: disp_fsa506.c fsa506_ebi.c
    ../../../common/drv_indev/: touch_st1663i.c
  group LCD43_V1_1
    ../../../common/drv_disp/: disp_nv3041a.c nv3041a_ebi.c
    ../../../common/drv_indev/: touch_gt911.c
  group NUTFT_V1_3
    ../../../common/drv_disp/: disp_ili9341.c ili9341_spi.c
    ../../../common/drv_indev/: touch_adc.c touch_adc_calibration.c
  group LCD5_V1_2
    ../../../common/drv_disp/: lt7381_ebi.c disp_lt7381.c
    ../../../common/drv_indev/: touch_ft5316.c
target LCD43_V1_0 (6240000::V6.24::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.1
  cpu: as above
  output: display_lcd43_v1_0
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: CONFIG_DISP_FSA506=1
  c include: as above
  asm define: m460
  asm include: ..\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0xf100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_m460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
target NUTFT_V1_3 (6240000::V6.24::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.1
  cpu: as above
  output: display_nutft_v1_3
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: as above
  c define: CONFIG_DISP_ILI9341=1
  c include: as above
  asm define: m460
  asm include: ..\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0xf100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: as above
target LCD5_V1_2 (6240000::V6.24::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.1
  cpu: as above
  output: display_nutft_v1_3
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: as above
  c define: CONFIG_DISP_LT7381=1
  c include: as above
  asm define: m460
  asm include: ..\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0xf100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: as above
